# Keil uVision project p-1_loader.uvprojx, settings and files
target p-1_loader (ARM-ADS)
  device: STM32L151RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: p-1_loader +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xD
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\Drivers\BSP\Adafruit_Shield;..\Drivers\BSP\STM32L1xx_Nucleo;..\Drivers\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group BSP
    ../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c
    ../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
    ../Drivers/BSP/: v1000_sd.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
    ./: startup_stm32l151xd.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc.c stm32l1xx_hal.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_tim.c stm32l1xx_hal_pwr.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_sd.c stm32l1xx_ll_sdmmc.c
  group Application/User
    ../Src/: stm32l1xx_hal_msp.c stm32l1xx_it.c user_diskio.c fatfs.c main.c stm_eeprom.c
software components: CMSIS:CORE 3.30.0
